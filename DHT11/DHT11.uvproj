# Keil uVision project DHT11.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: DHT11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DHT11;.\Delay;.\Printf
  group Source Group 1
    ./: main.c
    ./DHT11/: DHT11.c
    ./Delay/: Delay.c
    ./Printf/: UART_Printf.c
